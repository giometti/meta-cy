KERNEL_SRC = "git:///home/giometti/yocto/linux-engicam-nxp/"
SRCBRANCH = "5.15.71-cy"
SRCREV = "${AUTOREV}"
